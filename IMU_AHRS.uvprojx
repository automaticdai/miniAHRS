# Keil uVision project IMU_AHRS.uvprojx, settings and files
target IMU_AHRS (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IMU_AHRS +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startups
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Libraries
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group Drivers
    ./Hardware/: BMP180.c delay.c eeprom.c HMC5883L.c IMU.c IOI2C.c LED.c MPU6050.c UART2.c UARTs.c
  group User
    ./User_Src/: main.c stm32f10x_it.c
